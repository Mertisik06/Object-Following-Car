# Keil uVision project omni.uvprojx, settings and files
target Target (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: omni
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group
    ./: main.c startup.s PLL.c PortF.c SysTick.c PWM.c MotorControl.c UART.c Timers.c EdgeInterrupts.c PID.c Encoders.c Behaviors.c OmniControl.c Ultrasonic.c MotorDriver.c
software components: CMSIS:CORE 4.2.0
